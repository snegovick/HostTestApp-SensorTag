# IAR project HostTestRelease.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xPOWER_SAVING; xHAL_LED=FALSE; xHAL_KEY=FALSE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_ISR=0
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541EM-SBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xPOWER_SAVING; xHAL_LED=FALSE; xHAL_KEY=FALSE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_ISR=0; OAD_KEEP_NV_PAGES; MAKE_CRC_SHDW; FEATURE_SBL
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541EM-SBL\Exe\HostTestReleaseCC2541-SBL"
  XLINK.XclFile: cc254x_f256_sbl.xcl
configuration CC2541EM-EBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xPOWER_SAVING; xHAL_LED=FALSE; xHAL_KEY=FALSE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_ISR=0; OAD_KEEP_NV_PAGES; xMAKE_CRC_SHDW; FEATURE_EBL
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541EM-EBL\Exe\HostTestReleaseCC2541-EBL"
  XLINK.XclFile: cc254x_f256_ebl.xcl
configuration CC2541SPI (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2700; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=0; HAL_UART_SPI=2; HAL_SPI_QUEUED_TX=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
configuration CC2541SPI-SBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2700; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=0; HAL_UART_SPI=2; HAL_SPI_QUEUED_TX=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; OAD_KEEP_NV_PAGES; MAKE_CRC_SHDW; FEATURE_SBL
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541SPI-SBL\Exe\HostTestReleaseCC2541SPI-SBL"
  XLINK.XclFile: cc254x_f256_sbl.xcl
configuration CC2541SPI-EBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2700; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=0; HAL_UART_SPI=2; HAL_SPI_QUEUED_TX=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; OAD_KEEP_NV_PAGES; xMAKE_CRC_SHDW; FEATURE_EBL
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541SPI-EBL\Exe\HostTestReleaseCC2541SPI-EBL"
  XLINK.XclFile: cc254x_f256_ebl.xcl
  group APP
    ../Source/: hci_ext_app.c hci_ext_app.h HostTest_Main.c OSAL_HostTest.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_Full.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../../../Components/ble/include/: gatt_uuid.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
